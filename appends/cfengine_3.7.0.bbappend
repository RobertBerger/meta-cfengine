# we use the tarball, for some reason the git repo is broken (and not the same with the tarball)
SRC_URI = "http://s3.amazonaws.com/cfengine-package-repos/tarballs/cfengine-${PV}-2.tar.gz"

SRC_URI[md5sum] = "d2dc778f701eb1440c10608097fcf0f8"
SRC_URI[sha256sum] = "53e3fcae50b14d29a7a86920e13586cafed4eb5e2d081597dc9a7e34393c7f77"
